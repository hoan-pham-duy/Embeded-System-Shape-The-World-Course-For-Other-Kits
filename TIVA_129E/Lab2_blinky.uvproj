# Keil uVision project Lab2_blinky.uvproj, settings and files
target TM4C129E_blinky (ARM-ADS)
  device: TM4C129ENCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab2_blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: startup_TM4C129.s main.c
    C:/Keil/ARM/Startup/TI/TM4C129/: system_TM4C129.c
    C:/Keil/ARM/INC/TI/TM4C129/: TM4C129.h
